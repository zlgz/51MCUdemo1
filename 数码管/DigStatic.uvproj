# Keil uVision project DigStatic.uvproj, settings and files
target 静态数码管 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: DigStatic +hex
  c flags: Optimize=8 SizeSpeed=1
  group 起始代码
    ./: STARTUP.A51
  group 应用程序
    ./: main.c
