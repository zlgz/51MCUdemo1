# Keil uVision project led3.uvproj, settings and files
target LED流水灯 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: led3 +hex
  c flags: Optimize=8 SizeSpeed=1
  group 启动代码
    ./: STARTUP.A51
  group 主程序
    ./: main.c
